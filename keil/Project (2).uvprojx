# Keil uVision project Project (2).uvprojx, settings and files
target Project (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..;..\src\drivers;..\src\modules
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ../src/: startup.s main.c
    ../src/drivers/: ButtonLED.c I2C.c Servo.c UART0.c wtimer.c ButtonLED.h I2C.h Servo.h UART0.h wtimer.h
    ../src/modules/: LCD.c LCD.h MPU6050.c MPU6050.h TCS34727.h TCS34727.C
software components: CMSIS:CORE 5.6.0
